# Keil uVision project remote.uvprojx, settings and files
target remote (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: four rotor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\st_lib\inc;..\st_lib\src;..\driver;..\core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group driver
    ../driver/: systick.c led.c spi.c nrf24l01.c usart1.c usart3.c filter.c imath.c adc.c nvic.c sendpacket.c timing_trigger.c key.c pair_freq.c oled.c OledFont.c iic.c
  group st_lib
    ../st_lib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group core
    ../core/: core_cm3.c
  group startup
    ../core/: startup_stm32f10x_md.s
